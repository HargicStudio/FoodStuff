# IAR project Project.ewp, settings and files
configuration STM32F103RB_Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ..\Inc; ..\..\User; ..\..\Platform\AaSysLog; ..\..\Platform\AaMem; ..\..\Platform\AaThread; ..\..\Platform\AaTag; ..\..\Platform\CCSDeamon; ..\..\Platform\glo_def; ..\..\Common\BipBuffer; ..\..\STM32_Smart_V2.0_BSP; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F1xx_Nucleo; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
  group Application/User
    ../../User/: fastcheck.c led.c print_com.c tsc3200.c
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Platform
    ../../Platform/AaMem/: AaMem.c
    ../../Platform/AaSysLog/: AaSysLog.c
    ../../Platform/AaTag/: AaTag.c
    ../../Platform/AaThread/: AaThread.c
    ../../Platform/CCSDeamon/: CCSDeamon.c
  group Platform/Common
    ../../Common/BipBuffer/: BipBuffer.c
